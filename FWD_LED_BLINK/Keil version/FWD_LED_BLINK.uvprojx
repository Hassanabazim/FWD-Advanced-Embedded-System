# Keil uVision project FWD_LED_BLINK.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FWD_LED_BLINK +hex
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=1
  c include: .\HAL;.\MCAL;.\LIB;.\APP
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ./APP/: AppLcfg.c main.c
  group HAL
    ./HAL/: HPB_prog.c HLED_prog.c
  group MCAL
    ./MCAL/: MAFIO_prog.c MEXTI_prog.c MGPIO_prog.c MNVIC_prog.c MRCC_prog.c MSYSTICK_prog.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
